## boards/shields/micro_pad_3x3/Kconfig.defconfig
```kconfig
if SHIELD_MICRO_PAD_3X3

config ZMK_KEYBOARD_NAME
    default "MicroPad3x3"

endif
```
